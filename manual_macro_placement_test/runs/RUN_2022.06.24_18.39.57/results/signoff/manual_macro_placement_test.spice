* NGSPICE file created from manual_macro_placement_test.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for spm abstract view
.subckt spm clk p rst x[0] x[10] x[11] x[12] x[13] x[14] x[15] x[16] x[17] x[18] x[19]
+ x[1] x[20] x[21] x[22] x[23] x[24] x[25] x[26] x[27] x[28] x[29] x[2] x[30] x[31]
+ x[3] x[4] x[5] x[6] x[7] x[8] x[9] y VPWR VGND
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

.subckt manual_macro_placement_test VGND VPWR clk1 clk2 p1 p2 rst1 rst2 x1[0] x1[10]
+ x1[11] x1[12] x1[13] x1[14] x1[15] x1[16] x1[17] x1[18] x1[19] x1[1] x1[20] x1[21]
+ x1[22] x1[23] x1[24] x1[25] x1[26] x1[27] x1[28] x1[29] x1[2] x1[30] x1[31] x1[3]
+ x1[4] x1[5] x1[6] x1[7] x1[8] x1[9] x2[0] x2[10] x2[11] x2[12] x2[13] x2[14] x2[15]
+ x2[16] x2[17] x2[18] x2[19] x2[1] x2[20] x2[21] x2[22] x2[23] x2[24] x2[25] x2[26]
+ x2[27] x2[28] x2[29] x2[2] x2[30] x2[31] x2[3] x2[4] x2[5] x2[6] x2[7] x2[8] x2[9]
+ y1 y2
XFILLER_39_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_35 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_10 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_25 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput1 clk2 VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_101_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 rst1 VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput60 x2[31] VGND VGND VPWR VPWR input60/X sky130_fd_sc_hd__clkbuf_1
XFILLER_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_104_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput3 rst2 VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__clkbuf_1
XFILLER_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput50 x2[22] VGND VGND VPWR VPWR input50/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 x2[3] VGND VGND VPWR VPWR input61/X sky130_fd_sc_hd__clkbuf_2
XFILLER_107_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_11 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput4 x1[0] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__clkbuf_2
XFILLER_96_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput62 x2[4] VGND VGND VPWR VPWR input62/X sky130_fd_sc_hd__clkbuf_1
Xinput40 x2[13] VGND VGND VPWR VPWR input40/X sky130_fd_sc_hd__clkbuf_2
Xinput51 x2[23] VGND VGND VPWR VPWR input51/X sky130_fd_sc_hd__buf_2
XFILLER_103_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_23 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput5 x1[10] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__buf_2
XFILLER_91_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xspm_inst_0 clk1 output70/A input2/X input4/X input5/X input6/X input7/X input8/X
+ input9/X input10/X input11/X input12/X input13/X input14/X input15/X input16/X input17/X
+ input18/X input19/X input20/X input21/X input22/X input23/X input24/X input25/X
+ input26/X input27/X input28/X input29/X input30/X input31/X input32/X input33/X
+ input34/X input35/X input68/X VPWR spm_inst_0/VGND spm
XFILLER_102_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput63 x2[5] VGND VGND VPWR VPWR input63/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_107_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput30 x1[4] VGND VGND VPWR VPWR input30/X sky130_fd_sc_hd__buf_2
Xinput52 x2[24] VGND VGND VPWR VPWR input52/X sky130_fd_sc_hd__buf_2
Xinput41 x2[14] VGND VGND VPWR VPWR input41/X sky130_fd_sc_hd__buf_2
XFILLER_103_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_35 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput6 x1[11] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__clkbuf_2
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xspm_inst_1 input1/X output71/A input3/X input36/X input37/X input38/X input39/X input40/X
+ input41/X input42/X input43/X input44/X input45/X input46/X input47/X input48/X
+ input49/X input50/X input51/X input52/X input53/X input54/X input55/X input56/X
+ input57/X input58/X input59/X input60/X input61/X input62/X input63/X input64/X
+ input65/X input66/X input67/X input69/X VPWR spm_inst_1/VGND spm
XFILLER_28_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput31 x1[5] VGND VGND VPWR VPWR input31/X sky130_fd_sc_hd__clkbuf_2
Xinput20 x1[24] VGND VGND VPWR VPWR input20/X sky130_fd_sc_hd__clkbuf_1
XFILLER_103_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput64 x2[6] VGND VGND VPWR VPWR input64/X sky130_fd_sc_hd__clkbuf_2
Xinput53 x2[25] VGND VGND VPWR VPWR input53/X sky130_fd_sc_hd__clkbuf_1
Xinput42 x2[15] VGND VGND VPWR VPWR input42/X sky130_fd_sc_hd__buf_2
XFILLER_97_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 x1[12] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_20_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput32 x1[6] VGND VGND VPWR VPWR input32/X sky130_fd_sc_hd__buf_2
XFILLER_61_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput43 x2[16] VGND VGND VPWR VPWR input43/X sky130_fd_sc_hd__clkbuf_2
Xinput54 x2[26] VGND VGND VPWR VPWR input54/X sky130_fd_sc_hd__clkbuf_1
Xinput21 x1[25] VGND VGND VPWR VPWR input21/X sky130_fd_sc_hd__clkbuf_2
Xinput10 x1[15] VGND VGND VPWR VPWR input10/X sky130_fd_sc_hd__buf_2
Xinput65 x2[7] VGND VGND VPWR VPWR input65/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_89_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_151 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput8 x1[13] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__buf_2
XFILLER_24_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput44 x2[17] VGND VGND VPWR VPWR input44/X sky130_fd_sc_hd__clkbuf_1
Xinput55 x2[27] VGND VGND VPWR VPWR input55/X sky130_fd_sc_hd__clkbuf_2
Xinput33 x1[7] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__clkbuf_4
Xinput22 x1[26] VGND VGND VPWR VPWR input22/X sky130_fd_sc_hd__clkbuf_1
Xinput11 x1[16] VGND VGND VPWR VPWR input11/X sky130_fd_sc_hd__clkbuf_2
Xinput66 x2[8] VGND VGND VPWR VPWR input66/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_399 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput9 x1[14] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__buf_2
XFILLER_17_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput34 x1[8] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 x1[27] VGND VGND VPWR VPWR input23/X sky130_fd_sc_hd__clkbuf_1
Xinput56 x2[28] VGND VGND VPWR VPWR input56/X sky130_fd_sc_hd__clkbuf_1
Xinput12 x1[17] VGND VGND VPWR VPWR input12/X sky130_fd_sc_hd__clkbuf_4
Xinput45 x2[18] VGND VGND VPWR VPWR input45/X sky130_fd_sc_hd__clkbuf_2
Xinput67 x2[9] VGND VGND VPWR VPWR input67/X sky130_fd_sc_hd__buf_2
XFILLER_69_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 x1[18] VGND VGND VPWR VPWR input13/X sky130_fd_sc_hd__clkbuf_2
XFILLER_14_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput46 x2[19] VGND VGND VPWR VPWR input46/X sky130_fd_sc_hd__clkbuf_2
Xinput68 y1 VGND VGND VPWR VPWR input68/X sky130_fd_sc_hd__clkbuf_2
Xinput35 x1[9] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__clkbuf_2
Xinput57 x2[29] VGND VGND VPWR VPWR input57/X sky130_fd_sc_hd__clkbuf_2
Xinput24 x1[28] VGND VGND VPWR VPWR input24/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput25 x1[29] VGND VGND VPWR VPWR input25/X sky130_fd_sc_hd__buf_2
Xinput36 x2[0] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__clkbuf_1
Xinput14 x1[19] VGND VGND VPWR VPWR input14/X sky130_fd_sc_hd__clkbuf_2
XFILLER_14_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput47 x2[1] VGND VGND VPWR VPWR input47/X sky130_fd_sc_hd__clkbuf_2
Xinput69 y2 VGND VGND VPWR VPWR input69/X sky130_fd_sc_hd__clkbuf_1
Xinput58 x2[2] VGND VGND VPWR VPWR input58/X sky130_fd_sc_hd__clkbuf_2
XFILLER_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 x1[1] VGND VGND VPWR VPWR input15/X sky130_fd_sc_hd__buf_2
Xinput26 x1[2] VGND VGND VPWR VPWR input26/X sky130_fd_sc_hd__clkbuf_2
Xinput48 x2[20] VGND VGND VPWR VPWR input48/X sky130_fd_sc_hd__clkbuf_2
XFILLER_14_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput37 x2[10] VGND VGND VPWR VPWR input37/X sky130_fd_sc_hd__clkbuf_2
Xinput59 x2[30] VGND VGND VPWR VPWR input59/X sky130_fd_sc_hd__clkbuf_2
XFILLER_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 x1[20] VGND VGND VPWR VPWR input16/X sky130_fd_sc_hd__buf_2
Xinput38 x2[11] VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_1
Xinput49 x2[21] VGND VGND VPWR VPWR input49/X sky130_fd_sc_hd__clkbuf_4
Xinput27 x1[30] VGND VGND VPWR VPWR input27/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_6_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput28 x1[31] VGND VGND VPWR VPWR input28/X sky130_fd_sc_hd__clkbuf_1
Xinput39 x2[12] VGND VGND VPWR VPWR input39/X sky130_fd_sc_hd__clkbuf_4
Xinput17 x1[21] VGND VGND VPWR VPWR input17/X sky130_fd_sc_hd__clkbuf_1
XFILLER_6_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 x1[22] VGND VGND VPWR VPWR input18/X sky130_fd_sc_hd__buf_2
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput29 x1[3] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__buf_2
XFILLER_97_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 x1[23] VGND VGND VPWR VPWR input19/X sky130_fd_sc_hd__clkbuf_2
XFILLER_97_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_594 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_60_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput70 output70/A VGND VGND VPWR VPWR p1 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_98_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput71 output71/A VGND VGND VPWR VPWR p2 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_91_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_623 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_473 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_75_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
.ends
